require linux-libc-headers.inc

SRC_URI = "${KERNELORG_MIRROR}/linux/kernel/v3.0/linux-${PV}.tar.gz"

SRC_URI[md5sum] = "8c85f9d0962f2a9335028e4879b03343"
SRC_URI[sha256sum] = "073d6a589655031564407e349c86a316941fc26ef3444bb73a092b43a48347ec"

