SRC_URI = "http://mirrors.usc.edu/pub/gnu/libmicrohttpd/libmicrohttpd-0.4.6.tar.gz"
SRC_URI[md5sum] = "61698da6aa04744ea076c327f66fc05a"
SRC_URI[sha256sum] = "0cb09e26678d1531a4fd40a748abff5142bfdad3ae11cfe3bb7ad7317a99e371"

