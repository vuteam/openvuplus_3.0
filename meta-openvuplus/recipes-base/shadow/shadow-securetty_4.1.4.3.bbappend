PR .= "-vuplus0"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
