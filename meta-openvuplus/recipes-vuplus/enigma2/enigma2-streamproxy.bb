SUMMARY = "streamproxy manages streaming data to a PC using enigma2"
LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=59530bdf33659b29e73d4adb9f9f6552"
SRCREV = "37a3f198a22d90cdfebf07cf56409cf93a4e74ba"
PR = "r5"

SCHWERKRAFT_PROJECT = "streamproxy"

inherit autotools schwerkraft-git

