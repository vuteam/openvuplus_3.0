PR = "${INC_PR}.7"

RDEPENDS_${PN} = " \
"

require task-vuplus-enigma2.inc
