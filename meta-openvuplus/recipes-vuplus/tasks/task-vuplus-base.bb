PR = "${INC_PR}.1"

RDEPENDS_${PN} = " \
"

require task-vuplus-base.inc
