FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PR .= "-vuplus1"
