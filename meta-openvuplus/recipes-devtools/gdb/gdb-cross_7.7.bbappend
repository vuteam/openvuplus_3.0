PR .= "-vuplus0"

EXPAT = "--without-expat"
