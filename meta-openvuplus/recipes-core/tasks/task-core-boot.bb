PR = "${INC_PR}.2"

RDEPENDS_${PN} = " \
        "

require task-core-boot.inc
