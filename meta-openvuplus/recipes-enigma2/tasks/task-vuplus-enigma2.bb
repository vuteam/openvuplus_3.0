PR = "${INC_PR}.0"

RDEPENDS_${PN} = " \
  enigma2-streamproxy-xinetd \
"

require task-vuplus-enigma2.inc
