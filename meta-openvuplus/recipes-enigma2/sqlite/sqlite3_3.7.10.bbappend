PR .= "-vuplus0"

CFLAGS += "-DSQLITE_ENABLE_COLUMN_METADATA"
