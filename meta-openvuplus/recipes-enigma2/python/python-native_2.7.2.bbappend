RPROVIDES += "python-pickle-native python-pprint-native"

