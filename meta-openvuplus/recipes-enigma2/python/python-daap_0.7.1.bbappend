PR .= "-vuplus0"

SRC_URI += " \
	file://python-daap.patch \
"
