# Remove util-linux-mount from RRECOMMENDS

PR .= "-vuplus1"

RRECOMMENDS_ntfs-3g = ""

