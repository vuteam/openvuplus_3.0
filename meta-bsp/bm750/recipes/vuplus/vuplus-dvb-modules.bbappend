SRCDATE = "20131023"

MODULES_NAME = "procmk\ndvb-bcm7335\nbrcmfb"

SRC_URI[md5sum] = "4fa01c9e63b6cce0056c5fd8cba9766f"
SRC_URI[sha256sum] = "e982f740aea4ec5e37a670f16f983e7bce341568c11260c039505740a15fd692"
