require libgles.inc

COMPATIBLE_MACHINE = "^(vuuno4k)$"

SRCDATE = "20161129"
SRCDATE_PR = "r0"
PV="16.1"

S = "${WORKDIR}/libgles-vuuno4k"

SRC_URI[md5sum] = "d0bcd52cd7bd5161a8e0ccc09a70a91f"
SRC_URI[sha256sum] = "eb77af8982976fbc4cae75f2e6184afb97ce23261f83869ad0db54cde077611e"
