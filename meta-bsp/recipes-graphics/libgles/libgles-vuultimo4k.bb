require libgles.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"

SRCDATE = "20161129"
SRCDATE_PR = "r0"
PV="16.1"

S = "${WORKDIR}/libgles-vuultimo4k"

SRC_URI[md5sum] = "bce929b60bac3acd89860c0d1e102381"
SRC_URI[sha256sum] = "827f289d1a71844f6e2718c80db7c609bf45782fd56ed5addeb2f32b6d5c2de9"
