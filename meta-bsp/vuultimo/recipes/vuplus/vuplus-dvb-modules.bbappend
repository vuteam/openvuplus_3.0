SRCDATE = "20150317"

MODULES_NAME = "procmk\ndvb-bcm7413\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "49c3561be4f9d219e4e60d8e97748871"
SRC_URI[sha256sum] = "cec05afe8d37f45084daa685eda2d1f187bbf812926831548c5d15cdd76c5716"
