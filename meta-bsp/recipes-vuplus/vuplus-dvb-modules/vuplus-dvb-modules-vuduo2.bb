require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vuduo2)$"

SRCDATE = "20150317"

MODULES_NAME = "procmk\ndvb-bcm7424\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "c817f8d5b67a77318049f2d5bc3e7433"
SRC_URI[sha256sum] = "d3b2438de2e25aec08051851f2a81314a6e11f417a66dcfde49a11f3f2c449da"
