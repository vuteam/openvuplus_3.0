require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vusolose)$"

SRCDATE = "20150317"

MODULES_NAME = "procmk\ndvb-bcm7241\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "c714087e0528a142957f2c4630183914"
SRC_URI[sha256sum] = "7f7ec96cb8c2f3db3c07a56de3a8cd7aa0196692e56a9bf5bc315ce81fa7b33a"
