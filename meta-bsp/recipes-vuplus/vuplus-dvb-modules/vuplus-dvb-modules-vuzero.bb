require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vuzero)$"

SRCDATE = "20150317"

MODULES_NAME = "procmk\ndvb-bcm7362\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "0aa8809a5a23ee6ddba3c43e296c3196"
SRC_URI[sha256sum] = "8892eaa4010013a09b2743c4d52643f51005638a55193b13605dbaab49807611"
