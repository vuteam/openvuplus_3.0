require vuplus-dvb-modules.inc

COMPATIBLE_MACHINE = "^(vuuno)$"

SRCDATE = "20150317"

MODULES_NAME = "procmk\ndvb-bcm7413\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "2f4fb7d840c0dc6abd9ed45012334108"
SRC_URI[sha256sum] = "50f07c46334bbcc8f7890086975b2bdae5915ddf55fb8ed757d28f73c6dace71"
