require vuplus-manual.inc

COMPATIBLE_MACHINE = "^(vuduo2)$"

SRC_DATE = "20140429_p0"

SRC_URI[md5sum] = "0f9115e089f3aa393cbfe8258b5789fc"
SRC_URI[sha256sum] = "ef5f0ec0018b63dd46790341ee558c9f1e5f2bfd8c5863df1cd0eeee9e5a2910"

