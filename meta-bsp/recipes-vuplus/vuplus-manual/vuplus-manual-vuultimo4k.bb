require vuplus-manual.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"

SRC_DATE = "20161124_p0"

SRC_URI[md5sum] = "1d58685248293ac3e58d28f1171f7d81"
SRC_URI[sha256sum] = "78fe5f0319214994f34a0d9f765798b91a16e2e00fc779df6af27c4a0013575c"

