require vuplus-manual.inc

COMPATIBLE_MACHINE = "^(vusolo4k)$"

SRC_DATE = "20151007_p2"

SRC_URI[md5sum] = "4bc28b9f11eef3c0adee0c483aff487d"
SRC_URI[sha256sum] = "95c32abed18cb708a50947fd4b7ffceb7dfa0e2ab85e05974cba24665ef20824"

