require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vusolo4k)$"

PV="15.2"
SRCDATE = "20151128"
SRCDATE_PR = "r0"


SRC_URI[md5sum] = "aca2be07ad7320a00cdca094e45d619e"
SRC_URI[sha256sum] = "ac3683660b8bab9e450935cd63d4f184941aa8d5f7d5a57f4b021074546b8ec5"
