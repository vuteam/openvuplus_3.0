require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vusolose)$"

SRCDATE = "20161228"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "67503586616b33dc7a08446f3890241c"
SRC_URI[sha256sum] = "e03134a319d42bc37bd12366bfeab2de7ffbeb918b481bb194add689469b0ee9"
