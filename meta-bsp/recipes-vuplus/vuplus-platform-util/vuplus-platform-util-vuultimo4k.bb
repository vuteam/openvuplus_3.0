require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"

PV="16.1"
SRCDATE = "20161129"
SRCDATE_PR = "r0"


SRC_URI[md5sum] = "b06f339283219f04b65b196e7f1b9b98"
SRC_URI[sha256sum] = "cb75a84ec0ef77ecdfefb9651cff218654a2e6240ea690d501ade57e5151735a"
