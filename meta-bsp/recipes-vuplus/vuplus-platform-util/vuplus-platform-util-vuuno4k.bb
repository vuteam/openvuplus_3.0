require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vuuno4k)$"

PV="16.1"
SRCDATE = "20161129"
SRCDATE_PR = "r0"


SRC_URI[md5sum] = "714aa6154ae7bde452c26dcca64cbb39"
SRC_URI[sha256sum] = "4caf0cacbe364103a8f826b1ad5b2724cabee9f5220b48f202692b6b59608825"
