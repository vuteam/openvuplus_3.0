require vuplus-tuner-turbo.inc

COMPATIBLE_MACHINE = "^(vusolo4k)$"

SRC_URI = ""

do_install() {
}

ALLOW_EMPTY_${PN} = "1"
