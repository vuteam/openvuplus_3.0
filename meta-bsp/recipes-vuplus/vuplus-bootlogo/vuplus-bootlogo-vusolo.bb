require vuplus-bootlogo.inc

COMPATIBLE_MACHINE = "^(vusolo)$"

PR = "${INC_PR}.0"

