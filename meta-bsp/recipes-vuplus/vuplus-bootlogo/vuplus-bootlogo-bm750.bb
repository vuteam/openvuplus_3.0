require vuplus-bootlogo.inc

COMPATIBLE_MACHINE = "^(bm750)$"

PR = "${INC_PR}.0"

