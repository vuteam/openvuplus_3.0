FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"

PR .= "-bsp0"

SRC_URI += " \
        "


