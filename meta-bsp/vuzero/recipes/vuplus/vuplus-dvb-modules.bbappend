SRCDATE = "20141205"

MODULES_NAME = "procmk\ndvb-bcm7362\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "d5940eebf26ba488a6088f303cfe490b"
SRC_URI[sha256sum] = "630beefb2681cd39d7a18be233dfb0b05e1d52eddef6d663f9d8fda8859dd574"
