SRCDATE = "20131023"

MODULES_NAME = "procmk\ndvb-bcm7325\nbrcmfb"

SRC_URI[md5sum] = "6292537324779322762bc1844ee27cef"
SRC_URI[sha256sum] = "0a1f9ec376ad68d694fe30d1784f1eb124f5bec8f3c65730108d85829f7fff47"
