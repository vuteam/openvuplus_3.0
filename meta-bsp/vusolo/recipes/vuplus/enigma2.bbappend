SRC_URI_append = " file://enigma2_vuplus_misc.patch;patch=1;pnum=1"
