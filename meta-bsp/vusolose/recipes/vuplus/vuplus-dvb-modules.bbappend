SRCDATE = "20141231"

MODULES_NAME = "procmk\ndvb-bcm7241\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "39e998e5e25f200a855d9e59a132cb12"
SRC_URI[sha256sum] = "1720833ed331c9cdc62900e8c286f984b3ac2dfa5510a89f71915cc80eacc522"
