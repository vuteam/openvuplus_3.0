SRCDATE = "20150226"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "940a969b1ea67416837a459369a0837f"
SRC_URI[sha256sum] = "f347541c2aeb54ca648bb72b965cc9d82a11d2bd45522269e1ebd9af5992c66c"
