SRCDATE = "20150226"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "2f63dbd6d8728b5319be00159869d7df"
SRC_URI[sha256sum] = "9a8affa424b05b22da035ca3550d87cc937bfd38b7daae819f618cb744428f4c"
