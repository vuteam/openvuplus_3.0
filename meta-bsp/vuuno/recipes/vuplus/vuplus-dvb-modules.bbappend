SRCDATE = "20141231"

MODULES_NAME = "procmk\ndvb-bcm7413\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "3a641ddf749228940962e24a01e4cf45"
SRC_URI[sha256sum] = "52efbe6e073a69c96ae454283b829328c3a6a6278c8e738aebb4dd5672e5949a"
