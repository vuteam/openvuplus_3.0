SRC_URI_append = " file://enigma2_vuplus_textvfd.patch;patch=1;pnum=1"
