SRC_DATE = "20130717_p0"
IMAGE_DIR = "Vu+-Duo2-User-Manual_english_D0610-web-images"

SRC_URI[md5sum] = "c599a9b382a23fe0c40e5e0f8ba81801"
SRC_URI[sha256sum] = "315c9c29ba6b2d1b8f08b547132ec6a61979fa1a7f4bfdb60233cd6ab32c8004"
