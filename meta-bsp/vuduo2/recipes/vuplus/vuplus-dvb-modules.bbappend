SRCDATE = "20140306"

MODULES_NAME = "procmk\ndvb-bcm7424\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "99a3a46913e937691eddd2978dde1d32"
SRC_URI[sha256sum] = "533a774a02286944ba224a60ced2cf347e59a4d626a5a68ff6ba365becd28737"
