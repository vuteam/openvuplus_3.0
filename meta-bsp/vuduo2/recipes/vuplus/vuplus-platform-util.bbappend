SRCDATE = "20150226"
SRCDATE_PR = "r0"


SRC_URI[md5sum] = "e093c2d6f0186551c29e1e440f8f2595"
SRC_URI[sha256sum] = "368673779b0e101baa4dd50974124e2e62f4f090d9ebef34c8de00a719283260"
