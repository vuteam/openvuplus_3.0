SRCDATE = "20150226"
SRCDATE_PR = "r0"


SRC_URI[md5sum] = "8915fc55965a6747a652a68229917480"
SRC_URI[sha256sum] = "30a0eb0866fd84ffb1ee45eef8cbecd621234bab5747c97f997b1d14d4c5107c"
