PR .= "-bsp1"

SRC_URI_append = " file://enigma2_vuplus_1080p.patch;patch=1;pnum=1"
