SRC_DATE = "20140328_p0"
IMAGE_DIR = "image"

SRC_URI[md5sum] = "6fc4d9015f790f57b37220c088961b5a"
SRC_URI[sha256sum] = "ec99a9d9777e9a692089eb7d198bfd3298b70db0778d90dfc6b8262ab59cc68d"

