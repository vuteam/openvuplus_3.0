SRCDATE = "20150226"
SRCDATE_PR = "r0"


SRC_URI[md5sum] = "f126e04f0451c6cb7f234a0189b0bf46"
SRC_URI[sha256sum] = "4f7f960671198ce7228c368d457f27c4e9a3bc068ee99fbe442f815c10eb1342"
