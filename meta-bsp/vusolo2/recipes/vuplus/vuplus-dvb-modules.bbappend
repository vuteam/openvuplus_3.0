SRCDATE = "20130819"

MODULES_NAME = "procmk\ndvb-bcm7356\nbrcmfb\nfpga_directc"

SRC_URI[md5sum] = "5679c6659efed79e76a9fa7c90441187"
SRC_URI[sha256sum] = "aef4670afcba836c4652e5a33aa8c2a8d954b19e83adda7193d5058f20e3a27c"
