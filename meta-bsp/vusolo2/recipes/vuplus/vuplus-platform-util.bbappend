SRCDATE = "20150226"
SRCDATE_PR = "r0"


SRC_URI[md5sum] = "4e4b4272a7bdcd7634cda513ea1e9b4a"
SRC_URI[sha256sum] = "36a90872ea119dea51772658fc2b87d03b68c2e43c1a9f51ad794131c807c284"
