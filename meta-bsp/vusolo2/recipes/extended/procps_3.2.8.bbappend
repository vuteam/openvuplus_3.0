PR .= "-bsp0"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
