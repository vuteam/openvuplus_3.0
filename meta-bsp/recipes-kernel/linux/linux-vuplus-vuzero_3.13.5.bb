require linux-vuplus-3.13.5.inc

COMPATIBLE_MACHINE = "^(vuzero)$"

PR = "${INC_PR}.2"

SRC_URI += " \
        "


