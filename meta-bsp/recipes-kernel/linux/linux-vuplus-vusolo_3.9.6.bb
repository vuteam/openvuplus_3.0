require linux-vuplus-3.9.6.inc

COMPATIBLE_MACHINE = "^(vusolo)$"

PR = "${INC_PR}.5"

SRC_URI += "\
"
