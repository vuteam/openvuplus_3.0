require linux-vuplus-3.14.28.inc

COMPATIBLE_MACHINE = "^(vusolo4k)$"

PR = "${INC_PR}.6"

SRC_URI += "\
"
